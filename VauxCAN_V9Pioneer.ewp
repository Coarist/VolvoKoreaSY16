# IAR project VauxCAN_V9Pioneer.ewp, settings and files
configuration Debug (M16C, debug)
  General.GData16HeapSize: 1024
  General.GFarHeapSize: 1024
  General.GData20HeapSize: 1024
  General.GStackSize: 256
  General.GIStackSize: 64
  General.OGChipSelectMenu: R5F21236 R5F21236
  ICCM16C.CCDefines: DIAGS_ENABLED_NOT
  ICCM16C.newCCIncludePaths: Carside; Misc; R8C CAN; Radioside; vaux nm; ISO15765; ; Diags; Vauxhall Stalk
  ICCM16C.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: lnkR5F21236.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XlinkInterruptStackSize: 1
configuration Release (M16C)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: M16CGEN Generic M16C
  XLINK.XclFile: lnk0t.xcl
  group (top)
    R8C CAN/: can.c
    Carside/: carside.c
    Diags/: diags.c
    ISO15765/: iso15765.c
    ./: lnkR5F21236.xcl main.c
    Radioside/: radioside.c
    vaux nm/: vaux_nm.c
    Vauxhall Stalk/: vauxhall_stalk.c
    ../: Version History.txt
